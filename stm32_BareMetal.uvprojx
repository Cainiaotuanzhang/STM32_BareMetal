# Keil uVision project stm32_BareMetal.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32_BareMetal
  AfterMake: fromelf.exe --bin -o .\bin\STM32_BareMetal.bin .\Objects\STM32_BareMetal.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\src\CMSIS;.\STM32F4x7_ETH_Driver\inc;.\STM32F4xx_StdPeriph_Driver\inc;.\src\user;.\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./src/CMSIS/arm/: startup_stm32f40xx.s
    ./src/CMSIS/: stm32f4xx_it.c system_stm32f4xx.c
  group ETH_Driver
    ./STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group StdPeriph_Driver
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_iwdg.c
  group USER
    ./src/: asyn.c fun.c led.c sys_init.c
    ./src/user/: main.c
